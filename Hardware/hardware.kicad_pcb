# Repository CodonNine/foc

File README.md:

# 三相逆变器驱动板
## 1.设计指标
- 输入电压：24V-48V DC
- 输出电压：24V(RMS) AC
- 频率：50-60Hz
- 输出功率：60W
- 额定电流：10A

## 2.附加接口
- 一路5V-1A输出
- 输入电压分压采样输出
- 输出电压分压采样输出（加偏置）
- 三相桥低侧电流采样放大输出（加偏置）
- 带光耦隔离的三相PWM信号输入

## 3.元件选型
- 偏置电源：LP3985
- MOSFET：NCEP023N10 100V 300A
- 三相桥驱动器：eg2133
- 12V电源芯片：eg1198
- 5V电源芯片：ln3492
- 光耦：PC817

## KiCad design Hardware/hardware.kicad_pcb

Parts:
C21, C22, C23: 1u; C_0603_1608Metric
C24: 0.1u; C_0603_1608Metric
D4, D5, D6: FR107; D_SOD-123F
Q1, Q2, Q3, Q4, Q5, Q6: Q_NMOS_GSD; Infineon_PG-HSOF-8-1
R7, R8, R9, R10, R11, R12: 10; R_0603_1608Metric
R13, R14, R15: 0.01; R_2512_6332Metric
U5: EG2133; TSSOP-20_4.4x6.5mm_P0.65mm
U6: KF301-3P

Connections:
+12V: C24.1, D4.2 (A), D5.2 (A), D6.2 (A), U5.7 (VCC); also elsewhere on the board
/Bridge/HO1: R7.1, U5.19 (HO1)
/Bridge/HO2: R8.1, U5.16 (HO2)
/Bridge/HO3: R9.1, U5.13 (HO3)
/Bridge/IA_N: R13.2, U6.1; also elsewhere on the board
/Bridge/IB_N: R14.2, U6.2; also elsewhere on the board
/Bridge/IC_N: R15.2, U6.3; also elsewhere on the board
/Bridge/LO1: R10.1, U5.11 (LO1)
/Bridge/LO2: R11.1, U5.10 (LO2)
/Bridge/LO3: R12.1, U5.9 (LO3)
/Bridge/PWM1: U5.1 (HIN1), U5.4 (LIN1#); also elsewhere on the board
/Bridge/PWM2: U5.2 (HIN2), U5.5 (LIN2#); also elsewhere on the board
/Bridge/PWM3: U5.3 (HIN3), U5.6 (LIN3#); also elsewhere on the board
/Bridge/UA: C21.1, Q1.2 (S), Q2.3 (D), R13.1, U5.18 (VS1); also elsewhere on the board
/Bridge/UB: C22.1, Q3.2 (S), Q4.3 (D), R14.1, U5.15 (VS2); also elsewhere on the board
/Bridge/UC: C23.1, Q5.2 (S), Q6.3 (D), R15.1, U5.12 (VS3); also elsewhere on the board
GND: C24.2, Q2.2 (S), Q4.2 (S), Q6.2 (S), U5.8 (GND); also elsewhere on the board
unnamed: C21.2, D4.1 (K), U5.20 (VB1)
unnamed: C22.2, D5.1 (K), U5.17 (VB2)
unnamed: C23.2, D6.1 (K), U5.14 (VB3)
unnamed: Q1.1 (G), R7.2
unnamed: Q2.1 (G), R10.2
unnamed: Q3.1 (G), R8.2
unnamed: Q4.1 (G), R11.2
unnamed: Q5.1 (G), R9.2
unnamed: Q6.1 (G), R12.2
VDC: Q1.3 (D), Q3.3 (D), Q5.3 (D); also elsewhere on the board

Parts:
C25, C26, C27: 0.1u; C_0603_1608Metric
U7, U8, U9: INA240A1PW; TSSOP-8_4.4x3mm_P0.65mm

Connections:
+3.3V: C25.1, C26.1, C27.1, U7.5 (V+), U7.7 (REF1), U8.5 (V+), U8.7 (REF1), U9.5 (V+), U9.7 (REF1); also elsewhere on the board
/Bridge/IA_N: U7.3 (-); also elsewhere on the board
/Bridge/IB_N: U8.3 (-); also elsewhere on the board
/Bridge/IC_N: U9.3 (-); also elsewhere on the board
/Bridge/UA: U7.2 (+); also elsewhere on the board
/Bridge/UB: U8.2 (+); also elsewhere on the board
/Bridge/UC: U9.2 (+); also elsewhere on the board
/interface/IA_OUT: U7.8; also elsewhere on the board
/interface/IB_OUT: U8.8; also elsewhere on the board
/interface/IC_OUT: U9.8; also elsewhere on the board
GND: C25.2, C26.2, C27.2, U7.1 (GND), U7.4 (GND), U7.6 (REF2), U8.1 (GND), U8.4 (GND), U8.6 (REF2), U9.1 (GND), U9.4 (GND), U9.6 (REF2); also elsewhere on the board

Notes on the sheet:
1.输入电压9-36V 2.额定电流5A 3.最大功率180W 4.尺寸75mm*65mm
1.过流保护 2.过压保护 3.欠压保护 4.信号输入和输出线上的ESD防护
FOC控制器设计纲要
额定参数
保护措施

Parts:
J2: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical

Connections:
+5V: J2.9, J2.11, J2.13; also elsewhere on the board
/Bridge/PWM1: J2.2; also elsewhere on the board
/Bridge/PWM2: J2.4; also elsewhere on the board
/Bridge/PWM3: J2.6; also elsewhere on the board
/interface/IA_OUT: J2.10; also elsewhere on the board
/interface/IB_OUT: J2.12; also elsewhere on the board
/interface/IC_OUT: J2.14; also elsewhere on the board
GND: J2.1, J2.3, J2.5; also elsewhere on the board

Parts:
C1, C4, C6, C8, C20, C28: 0.1u; C_0603_1608Metric
C2, C3, C5: 22u; C_0603_1608Metric
C7, C12, C19: 10u; C_0603_1608Metric
C9: 22u 100V
C10, C11, C13, C14, C15, C16, C17, C18: 22u 100V; C_1206_3216Metric
D1: 1N5819; D_SOD-123
D2: LED; LED_0603_1608Metric
D3: FR107; D_SOD-123F
F1: Fuse; 1808-FuseBase-SMD
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
L1: 4.7u; L_Chilisin_BMRA00040420
L2: 47u; L_Chilisin_BMRA00040420
R1, R5: 10k; R_0603_1608Metric
R2: 190k; R_0603_1608Metric
R3: 150k; R_0603_1608Metric
R4: 1M; R_0603_1608Metric
R6: 20.5k; R_0603_1608Metric
U1: LP5907MFX-3.3; SOT-23-5
U2: SX1308; SOT-23-6
U3: ME3116; SOT-23-6
U4: KF301-2P

Connections:
+3.3V: C19.2, C20.2, U1.5 (OUT); also elsewhere on the board
+5V: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, L1.2, L2.2, R1.2, R3.1, U1.1 (IN), U1.3 (EN), U2.4 (EN), U2.5 (IN); also elsewhere on the board
+12V: C12.2, C28.2, D1.1 (K), R2.1; also elsewhere on the board
/power/FB1: R3.2, R6.1, U3.3 (FB)
/power/FB2: R2.2, R5.1, U2.3 (FB)
/power/VIN: F1.1, U4.1
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C28.1, D2.1 (K), D3.2 (A), R5.2, R6.2, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2; also elsewhere on the board
unnamed: D2.2 (A), R1.1
unnamed: C1.1, U3.1 (BS)
unnamed: R4.2, U3.4 (EN)
SW1: C1.2, D3.1 (K), L2.1, U3.6 (SW)
SW2: D1.2 (A), L1.1, U2.1 (SW)
VDC: C9.1, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, F1.2, R4.1, U3.5 (IN); also elsewhere on the board

Notes on the sheet:
靠近U3 1脚放置
靠近U2 5脚放置
靠近输入保险丝放置
靠近U1 5脚放置
靠近MOSFET上桥臂放置，每管2个
靠近U1输出电感

Board: 4 copper layers, 60.0 x 80.0 mm, 71 parts (0 on the bottom side), 40 nets.

## KiCad design Hardware/Inverter.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via

Connections:
GNDPWR: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Parts:
J1: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical

Connections:
+5V: J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19; also elsewhere on the board
/三相桥及驱动/PWM_IN1: J1.1; also elsewhere on the board
/三相桥及驱动/PWM_IN2: J1.3; also elsewhere on the board
/三相桥及驱动/PWM_IN3: J1.5; also elsewhere on the board
/接口/IA_OUT: J1.8; also elsewhere on the board
/接口/IB_OUT: J1.10; also elsewhere on the board
/接口/IC_OUT: J1.12; also elsewhere on the board
/接口/UA_OUT: J1.2; also elsewhere on the board
/接口/UB_OUT: J1.4; also elsewhere on the board
/接口/UC_OUT: J1.6; also elsewhere on the board
GND: J1.14, J1.16, J1.18, J1.20; also elsewhere on the board

Parts:
C32, C33, C34, C35: 0.1u; C_0603_1608Metric
R22, R23: 10k; R_0603_1608Metric
R24, R25, R26, R27, R29, R31, R33, R34, R35: 3k; R_0603_1608Metric
R28, R30, R32, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47: 1k; R_0603_1608Metric
U11, U12, U13: INA181; SOT-23-6
U14: LM324; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3.3V: C32.2, C33.2, C34.2, C35.2, R22.1, U11.6 (V+), U12.6 (V+), U13.6 (V+), U14.4 (V+); also elsewhere on the board
/三相桥及驱动/IA: U11.3 (+); also elsewhere on the board
/三相桥及驱动/IB: U12.3 (+); also elsewhere on the board
/三相桥及驱动/IC: U13.3 (+); also elsewhere on the board
/接口/IA_OUT: U11.1; also elsewhere on the board
/接口/IB_OUT: U12.1; also elsewhere on the board
/接口/IC_OUT: U13.1; also elsewhere on the board
/接口/UA_OUT: R32.2, R44.1, R47.1, U14.6 (-), U14.7; also elsewhere on the board
/接口/UB_OUT: R30.2, R42.1, R46.1, U14.13 (-), U14.14; also elsewhere on the board
/接口/UC_OUT: R28.2, R40.1, R45.1, U14.8, U14.9 (-); also elsewhere on the board
/电流电压采样/1.65V REF: R45.2, R46.2, R47.2, U11.5 (REF), U12.5 (REF), U13.5 (REF), U14.1, U14.2 (-)
GND: C32.1, C33.1, C34.1, C35.1, R23.2, U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.11 (V-); also elsewhere on the board
GNDPWR: R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, U11.4 (-), U12.4 (-), U13.4 (-); also elsewhere on the board
unnamed: R24.2, R27.1
unnamed: R25.2, R29.1
unnamed: R26.2, R31.1
unnamed: R27.2, R33.1
unnamed: R29.2, R34.1
unnamed: R31.2, R35.1
unnamed: R33.2, R36.1, R39.1
unnamed: R34.2, R37.1, R41.1
unnamed: R35.2, R38.1, R43.1
unnamed: R22.2, R23.1, U14.3 (+)
unnamed: R32.1, R38.2, U14.5 (+)
unnamed: R28.1, R36.2, U14.10 (+)
unnamed: R30.1, R37.2, U14.12 (+)
UA: R25.1, R26.1; also elsewhere on the board
UB: R24.1; also elsewhere on the board

Parts:
C1, C2, C3: 1uF 50V; C_1206_3216Metric
C4: 0.1u; C_1206_3216Metric
C5: 22u; C_1206_3216Metric
D1, D2, D3: FR107; D_SOD-123F
Q1, Q2, Q3, Q4, Q5, Q6: NCEP023N10LL; PG-HSOF-8-1_L10.4-W9.9-P1.2-LS11.7-TL
R1, R2, R3, R6, R8, R10: 10; R_0603_1608Metric
R4, R5, R12, R13, R14, R15: 1k; R_0603_1608Metric
R7, R9, R11: 0.01; R_2512_6332Metric
U1, U2, U3: PC817; DIP-4_W7.62mm
U4: EG2133; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+5V: U1.4, U2.4, U3.4; also elsewhere on the board
+12V: C4.2, C5.2, D1.2 (A), D2.2 (A), D3.2 (A), U4.7 (VCC); also elsewhere on the board
/三相桥及驱动/HO1: R1.2, U4.19 (HO1)
/三相桥及驱动/HO2: R2.2, U4.16 (HO2)
/三相桥及驱动/HO3: R3.2, U4.13 (HO3)
/三相桥及驱动/IA: Q4.2 (S), Q4.3 (S), Q4.4 (S), Q4.5 (S), Q4.6 (S), Q4.7 (S), Q4.8 (S), R7.1; also elsewhere on the board
/三相桥及驱动/IB: Q5.2 (S), Q5.3 (S), Q5.4 (S), Q5.5 (S), Q5.6 (S), Q5.7 (S), Q5.8 (S), R9.1; also elsewhere on the board
/三相桥及驱动/IC: Q6.2 (S), Q6.3 (S), Q6.4 (S), Q6.5 (S), Q6.6 (S), Q6.7 (S), Q6.8 (S), R11.1; also elsewhere on the board
/三相桥及驱动/LO1: R6.2, U4.11 (LO1)
/三相桥及驱动/LO2: R8.2, U4.10 (LO2)
/三相桥及驱动/LO3: R10.2, U4.9 (LO3)
/三相桥及驱动/PWM_IN1: U1.1; also elsewhere on the board
/三相桥及驱动/PWM_IN2: U2.1; also elsewhere on the board
/三相桥及驱动/PWM_IN3: U3.1; also elsewhere on the board
/三相桥及驱动/PWM_OUT1: R5.1, U1.3, U4.1 (HIN1), U4.4 (LIN1#)
/三相桥及驱动/PWM_OUT2: R13.1, U2.3, U4.2 (HIN2), U4.5 (LIN2#)
/三相桥及驱动/PWM_OUT3: R15.1, U3.3, U4.3 (HIN3), U4.6 (LIN3#)
GND: R4.2, R12.2, R14.2; also elsewhere on the board
GNDPWR: C4.1, C5.1, R5.2, R7.2, R9.2, R11.2, R13.2, R15.2, U4.8 (GND); also elsewhere on the board
unnamed: C1.2, D1.1 (K), U4.20 (VB1)
unnamed: C2.2, D2.1 (K), U4.17 (VB2)
unnamed: C3.2, D3.1 (K), U4.14 (VB3)
unnamed: Q1.1 (G), R1.1
unnamed: Q2.1 (G), R2.1
unnamed: Q3.1 (G), R3.1
unnamed: Q4.1 (G), R6.1
unnamed: Q5.1 (G), R8.1
unnamed: Q6.1 (G), R10.1
unnamed: R4.1, U1.2
unnamed: R12.1, U2.2
unnamed: R14.1, U3.2
UA: C1.1, Q1.2 (S), Q1.3 (S), Q1.4 (S), Q1.5 (S), Q1.6 (S), Q1.7 (S), Q1.8 (S), Q4.9 (D), U4.18 (VS1); also elsewhere on the board
UB: C2.1, Q2.2 (S), Q2.3 (S), Q2.4 (S), Q2.5 (S), Q2.6 (S), Q2.7 (S), Q2.8 (S), Q5.9 (D), U4.15 (VS2); also elsewhere on the board
UC: C3.1, Q3.2 (S), Q3.3 (S), Q3.4 (S), Q3.5 (S), Q3.6 (S), Q3.7 (S), Q3.8 (S), Q6.9 (D), U4.12 (VS3); also elsewhere on the board
VDC: Q1.9 (D), Q2.9 (D), Q3.9 (D); also elsewhere on the board

Parts:
C6, C7: 1u; C_0603_1608Metric
C8: 0.1uF 100V; C_1206_3216Metric
C9, C10, C11: 22u; C_1206_3216Metric
C13: 47u 100V; CP_Radial_D10.0mm_P5.00mm
C14, C21: 22u 100V *6; C_1206_3216Metric
C15, C16, C17, C18, C19, C20, C22, C23, C24, C25, C26: C; C_1206_3216Metric
C27, C29, C31: 0.1u; C_0603_1608Metric
C28, C30: 22u; C_0603_1608Metric
D4: FR107; D_SOD-123F
D5: SMF5V0A; D_SMF
F1: Fuse; FUSE-SMD_L9.7-W5.0
L1: 100u; L_Chilisin_BMRB00060650
L2: 100u; IND-SMD_L4.0-W4.0_0.47UH04209.5A
R16: 0.15; R_1206_3216Metric
R17: 3k; R_0603_1608Metric
R18: 1k; R_0603_1608Metric
R19: 0; R_0603_1608Metric
R20: 150k; R_0603_1608Metric
R21: 20.5k; R_0603_1608Metric
U5: EG1198; ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP-1
U6: LP5907MFX-3.3; SOT-23-5
U7: KF301-5.0-2P; CONN-TH_P5.00_KF301-5.0-2P
U8: SS12D06弯针; SW-TH_3P-SS12D06-1
U9: KF301-5.0-3P; CONN-TH_3P-P5.00_KF301-5.0-3P
U10: SOT-23-6

Connections:
+3.3V: C7.2, U6.5 (OUT); also elsewhere on the board
+5V: C6.2, C30.2, C31.2, D5.1 (A1), L2.2, R20.2, U6.1 (IN), U6.3 (EN); also elsewhere on the board
+12V: C9.2, C10.2, C11.2, C28.2, C29.2, L1.2, R17.2, U10.4 (EN), U10.5 (VIN); also elsewhere on the board
/电源/FB1: R17.1, R18.2, U5.4 (FB)
/电源/FB2: R20.1, R21.2, U10.3 (FB)
/电源/FUSE: F1.2, U7.1
/电源/IS: R16.2, U5.8 (IS)
/电源/SW1: C8.2, D4.1 (K), L1.1, R16.1, U5.7 (VS)
/电源/SW2: C27.1, L2.1, U10.6 (SW)
/电源/VIN: F1.1, U8.3
GND: C6.1, C7.1, C28.1, C29.1, R19.2, U6.2 (GND); also elsewhere on the board
GNDPWR: C9.1, C10.1, C11.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C30.1, C31.1, D4.2 (A), D5.2 (A2), R18.1, R19.1, R21.1, U5.2 (GND), U7.2, U10.2 (GND); also elsewhere on the board
unnamed: C8.1, U5.6 (VB)
unnamed: C27.2, U10.1 (BST)
UA: U9.1; also elsewhere on the board
UB: U9.2; also elsewhere on the board
UC: U9.3; also elsewhere on the board
VDC: C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, U5.1 (VIN), U5.9 (VIN), U8.2; also elsewhere on the board

Board: 2 copper layers, 95.0 x 70.0 mm, 114 parts (0 on the bottom side), 65 nets.

## Commit log

2024-02-24 硬件完成
